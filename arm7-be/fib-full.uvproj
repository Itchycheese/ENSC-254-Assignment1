# Keil uVision project fib-full.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: fib-full
  group Source Group 1
    ./: fib-full.s
